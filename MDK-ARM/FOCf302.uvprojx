# Keil uVision project FOCf302.uvprojx, settings and files
target Target1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F302CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FOCf302
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,ARM_MATH_CM4=1
  c misc: --C99
  c include: ..\CMSIS\Include;..\STM32F3xx_HAL_Driver\Inc;..\STM32F3xx_HAL_Driver\src;..\Inc;..\Src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Src/: system_stm32f3xx.c
    ../CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group MDK-ARM
    ./: startup_stm32f302xc.s
  group Drivers
    ../STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c
  group User
    ../Src/: adc.c board.c exti_it.c foc.c foc_param.c fun.c main.c POS.c pwm.c QEI.c mag.c stm32f3xx_it.c
